<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bldc_sinus.ewp</path>
  </project>
  <batchBuild/>
</workspace>


