# IAR project Backup of bldc_sinus.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0x40
  General.SCRStackSize: 0x10
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: ..\..\..\common; ..\..\common; ..\common; ..\..\..; ..\..; ..; uart; $PROJ_DIR$
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgpwm3.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: adc.c ascii.c init.c main.c mc_control.c mc_drv.c mc_interface.c ushell_task.c
    ../../../common/lib_mcu/comparator/: comparator_drv.c
    uart/: uart_lib.c
  group Doc
    ./: html_doc.h
